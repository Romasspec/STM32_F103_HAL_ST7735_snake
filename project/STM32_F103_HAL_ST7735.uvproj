# Keil uVision project STM32_F103_HAL_ST7735.uvproj, settings and files
target STM32_HAL_ST7735 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_F103_HAL_ST7735 +hex
  c flags: Optim=1
  c define: STM32F103xB
  c misc: --c99
  c include: ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\CMSIS\Device\ST\STM32F1xx\Source\Templates;..\Drivers\CMSIS\Device\ST\STM32F1xx\Source\Templates\arm;..\Drivers\CMSIS\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Src;..\Inc;..\Src;..\startup
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ../Src/: fonts.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c ILI9341_GFX.c ILI9341_STM32_Driver.c main.c tm_stm32f1_fonts.c
  group Inc
    ../Inc/: fonts.h ILI9341_GFX.h ILI9341_STM32_Driver.h main.h stm32f1xx_hal_conf.h stm32f1xx_it.h tm_stm32f1_fonts.h
  group Driver
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal.h stm32f1xx_hal_cortex.h stm32f1xx_hal_dma.h stm32f1xx_hal_flash.h stm32f1xx_hal_gpio.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_spi.h
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_spi.c stm32f1xx_hal_flash_ex.c
  group CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include/: stm32f1xx.h system_stm32f1xx.h stm32f103xb.h
    ../Drivers/CMSIS/Include/: core_cm3.h
  group Startup
    ../startup/: startup_stm32f10x_md.s
